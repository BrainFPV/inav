# Keil uVision project ch.uvprojx, settings and files
target Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ch
  c flags: Optim=3 oTime=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CORTEX_USE_FPU=1 __heap_base__=Image$$$$RW_IRAM1$$$$ZI$$$$Limit __heap_end__=Image$$$$RW_IRAM2$$$$Base
  c misc: -USTM32F407xx
  c include: ..\;..\cfg;..\..\..\..\..\os\license;..\..\..\..\..\os\common\startup\ARMCMx\devices\STM32F4xx;..\..\..\..\..\os\common\ext\ARM\CMSIS\Core\Include;..\..\..\..\..\os\common\ext\ST\STM32F4xx;..\..\..\..\..\os\common\ports\ARMCMx;..\..\..\..\..\os\common\ports\ARMCMx\compilers\RVCT;..\..\..\..\..\os\rt\include;..\..\..\..\..\os\oslib\include;..\..\..\..\..\os\hal\osal\rt-nil;..\..\..\..\..\os\hal\include;..\..\..\..\..\os\hal\lib\streams;..\..\..\..\..\os\hal\boards\ST_STM32F4_DISCOVERY;..\..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\..\os\hal\ports\common\ARMCMx;..\..\..\..\..\os\hal\ports\STM32\STM32F4xx;..\..\..\..\..\os\hal\ports\STM32\LLD\ADCv2;..\..\..\..\..\os\hal\ports\STM32\LLD\CANv1;..\..\..\..\..\os\hal\ports\STM32\LLD\CRYPv1;..\..\..\..\..\os\hal\ports\STM32\LLD\DACv1;..\..\..\..\..\os\hal\ports\STM32\LLD\DMAv2;..\..\..\..\..\os\hal\ports\STM32\LLD\EXTIv1;..\..\..\..\..\os\hal\ports\STM32\LLD\GPIOv2;..\..\..\..\..\os\hal\ports\STM32\LLD\I2Cv1;..\..\..\..\..\os\hal\ports\STM32\LLD\MACv1;..\..\..\..\..\os\hal\ports\STM32\LLD\OTGv1;..\..\..\..\..\os\hal\ports\STM32\LLD\QUADSPIv1;..\..\..\..\..\os\hal\ports\STM32\LLD\RTCv2;..\..\..\..\..\os\hal\ports\STM32\LLD\SPIv2;..\..\..\..\..\os\hal\ports\STM32\LLD\SDIOv1;..\..\..\..\..\os\hal\ports\STM32\LLD\TIMv1;..\..\..\..\..\os\hal\ports\STM32\LLD\USARTv1;..\..\..\..\..\os\hal\ports\STM32\LLD\xWDGv1;..\..\..\..\..\testhal\common
  asm misc: --cpreproc --cpreproc_opts=-D,CORTEX_USE_FPU=1
  asm include: ..\;..\cfg;..\..\..\..\..\os\license;..\..\..\..\..\os\common\startup\ARMCMx\devices\STM32F4xx;..\..\..\..\..\os\common\ports\ARMCMx;..\..\..\..\..\os\hal\boards\ST_STM32F4_DISCOVERY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20020000 size 0x1
  group startup
    ../../../../../os/common/startup/ARMCMx/compilers/RVCT/: cstartup.s vectors.s
  group kernel
    ../../../../../os/rt/src/: chvt.c chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c
  group kernel_port
    ../../../../../os/common/ports/ARMCMx/: chcore.c chcore_v7m.c
    ../../../../../os/common/ports/ARMCMx/compilers/RVCT/: chcoreasm_v7m.s
  group oslib
    ../../../../../os/oslib/src/: chdelegates.c chfactory.c chmboxes.c chmemcore.c chmemheaps.c chmempools.c chobjcaches.c chpipes.c
  group osal
    ../../../../../os/hal/osal/rt-nil/: osal.c
  group hal
    ../../../../../os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_crypto.c hal_dac.c hal_efl.c hal_flash.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_sio.c hal_spi.c hal_st.c hal_trng.c hal_uart.c hal_usb.c hal_wdg.c hal_wspi.c
  group hal_port
    ../../../../../os/hal/ports/STM32/STM32F4xx/: hal_efl_lld.c hal_lld.c stm32_isr.c
    ../../../../../os/hal/ports/STM32/LLD/ADCv2/: hal_adc_lld.c
    ../../../../../os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c
    ../../../../../os/hal/ports/STM32/LLD/CRYPv1/: hal_crypto_lld.c
    ../../../../../os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c
    ../../../../../os/hal/ports/STM32/LLD/DMAv2/: stm32_dma.c
    ../../../../../os/hal/ports/STM32/LLD/EXTIv1/: stm32_exti.c
    ../../../../../os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
    ../../../../../os/hal/ports/STM32/LLD/I2Cv1/: hal_i2c_lld.c
    ../../../../../os/hal/ports/STM32/LLD/MACv1/: hal_mac_lld.c
    ../../../../../os/hal/ports/STM32/LLD/OTGv1/: hal_usb_lld.c
    ../../../../../os/hal/ports/STM32/LLD/QUADSPIv1/: hal_wspi_lld.c
    ../../../../../os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
    ../../../../../os/hal/ports/STM32/LLD/SPIv1/: hal_i2s_lld.c hal_spi_lld.c
    ../../../../../os/hal/ports/STM32/LLD/SDIOv1/: hal_sdc_lld.c
    ../../../../../os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c hal_st_lld.c
    ../../../../../os/hal/ports/STM32/LLD/USARTv1/: hal_serial_lld.c hal_uart_lld.c
    ../../../../../os/hal/ports/STM32/LLD/xWDGv1/: hal_wdg_lld.c
    ../../../../../os/hal/ports/common/ARMCMx/: nvic.c
  group hal_lib
    ../../../../../os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
  group board
    ../../../../../os/hal/boards/ST_STM32F4_DISCOVERY/: board.c
  group test
    ../../../../common/: irq_storm.c
  group demo
    ../: main.c mcuconf.h chconf.h halconf.h extfunc.c
